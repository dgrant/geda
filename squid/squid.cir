* gnetlist -g spice-sdb -o squid.cir squid.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 10.9.2004 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
X2 1 0 josephson_junction params: Ic=40u Rq=1 phase=0
X1 out 0 josephson_junction params: Ic=35u Rq=1 phase=0
I1 out 0 DC 1uA
.INCLUDE ./simulation.cmd
B1 1 out I=time*({Imax}-30u)/{Tmax}+30u
*vvvvvvvv  Included SPICE model from ./jj.subckt vvvvvvvv
* jj subcircuit
.subckt josephson_junction n1 n2
C1 n1 n2 {C}
B1 n1 n2 I={Ic}*sin(V(n,n2))+((1+{a}*cos(V(n,n2))/{Rq})*V(n1,n2))
B2 n2 n I={k}*V(n1,n2)
R1 n n2 {Rn}
C2 n n2 {Cn} IC={phase}
.param Ic=35u a=0 Rq=1 C=10f
.param k=3000 Cn=1p Rn=1G phase=0
.ends josephson_junction
*^^^^^^^^  End of included SPICE model from ./jj.subckt ^^^^^^^^
*
.END
