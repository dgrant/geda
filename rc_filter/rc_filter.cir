* gnetlist -g spice-sdb -o rc_filter.cir rc_filter.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 10.9.2004 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
.INCLUDE simulation.cmd
V1 in 0 DC 1V
R1 in out 1k
C1 out 0 1uF
.END
